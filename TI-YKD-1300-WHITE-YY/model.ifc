Properties of the parts of a building model (IFC4)

# File
Description: Traffic Industries product reference geometry and properties; local coordinates
File name: model.ifc
Time: 2026-09-20T21:29:46Z
Author: MIR GROUP
Organization: MIR GROUP
Written by: IfcOpenShell 0.8.4
Made in: Traffic Industries EN1

# IfcProject, Traffic Industries / MIR GROUP product library
LongName: Roadside delineator 1300 - white body / yellow front / yellow back

# IfcBuilding, Local product coordinate container
Description: Generic model container; not an actual building or geographic location

# IfcBuildingElementProxy: Roadside delineator posts, Roadside delineator 1300 - white body / yellow front / yellow back
In: Local product coordinate container
Description: Traffic Industries product; MIR GROUP; PredefinedType: USERDEFINED; Document: Roadside delineator 1300 - white body / yellow front / yellow back https://trafficindustries.com/en/products/lane-guidance/roadside-delineator-posts/; Material: Glass reinforced polymer (GRP / CTP)
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductCode: TI-YKD-1300-WHITE-YY; ProductName: Roadside delineator 1300 - white body / yellow front / yellow back; ProductGroup: Roadside delineator posts; ProductWebsite: https://trafficindustries.com/en/products/lane-guidance/roadside-delineator-posts/; DesignRevision: CAD-R2; DocumentRevision: EN1; DrawingLanguage: English; IssueDate: 2026-09-09; DesignStatus: Accepted body geometry; manufacturer-source annotations added for review; LengthUnit: mm; CoordinateSystem: Local product coordinates; X=0 to 100, Y=0 to 10, tip Z=0; Z up; no geospatial CRS; OverallWidth_mm: 100; OverallDepth_mm: 10; OverallHeight_mm: 1300; NormalWall_mm: 3; ConcaveFlatEachSide_mm: 10; VisibleHeight_mm: 800; BuriedLength_mm: 500; BottomTipHeight_mm: 100; TopShape: Flat; InnerRadiusCalculated_mm: 117.786; OuterRadiusCalculated_mm: 120.786; CurveBasis: Circular reconstruction; radius not measured in source; corner transition radii not specified; Material: GRP / CTP: glass fibre roving and mat with thermally reacting polymer resin; MeasuredWeight_kg: Not measured; MaterialDensity: Not verified; BodyColour: white; FrontFace: Concave; BackFace: Convex; FrontReflectorColour: yellow; BackReflectorColour: yellow; ReflectorsPerFace: 1; ReflectorWidth_mm: 70; ReflectorHeight_mm: 150; ReflectorTopGap_mm: 100; ReflectorSideMargin_mm: 15; ReflectorBottomZ_mm: 1050; ReflectorTopZ_mm: 1200; ReflectorThickness: Not specified; appearance surface only; OpticalClass: Not verified; BodySectionArea_mm2: 304.839; BodyVolume_mm3: 380997; Mounting: Direct burial in ground; 500 mm nominal burial; PhysicalSampleDimensions: Not independently measured; PaintAndRGB: Display colour approximation; not a colourimetric measurement; SourceGeometrySHA256: ba6b8dedcd1c2ee51606250194fa06efcd67f265c0804c68d085fc2e1a063016; NormalWallBasis: 3 mm on circular and flat regions; corner transition has no specified radius; FrontMarkLetterHeight_mm: 30; FrontMarkLetterGap_mm: 20; FrontMarkLineCount: 3; FrontMarkBottomZ_mm: 820; FrontMarkTopZ_mm: 950; FrontMarkContent: Authority-selected content; source TCK is an example, not a fixed product marking; FrontMarkLetterWidth: Not dimensioned in source; RearMarkWidth_mm: 70; RearMarkHeight_mm: 50; RearMarkBottomZ_mm: 600; RearMarkTopZ_mm: 650; RearMarkContent: Manufacturer name and actual manufacturing date; date not assigned in CAD; RearCharacterHeight: Not dimensioned in source; MarkingGeometry: Reserved surface areas / annotations only; no added or removed body volume; LengthOptions_mm: 1150 / 1300 / 1500; LengthOptionSource: Only 1300 mm is dimensioned in source S5; 1150/1500 are listed offering lengths and have no built geometry in this release; ReflectorStandardReference: ASTM D4956 (source prints ASTM 4956); optical class and compliance not independently verified; ColourApplication: As specified by the contracting authority and market scheme; no universal left/right assignment; PublishedTestBasis: Contract-manufacturer published test requirements; not a supplied laboratory report or a new test performed for this CAD release; PublishedTestDocumentDate: 2019-02-28; PublishedTestCriteria_JSON: [{"id":"S5-T01","name_en":"Yellowing index and yellow-body colour coordinates","standard_as_printed":"ASTM 313 / CIE Lab","criterion":{"white_yellowing_index_max":12,"yellow_L_star":[72,76],"yellow_a_star":[10,14],"yellow_b_star":[81,85]},"conditions":{"measurement_geometry_deg":"45 / 0","observer_deg":2,"illuminant":"D65","instrument":"Spectrophotometer"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T02","name_en":"Water absorption","standard_as_printed":"EN ISO 62","criterion":{"maximum_percent":0.4},"conditions":{"sample_mm":[50,50],"immersion_hours":24,"measurement":"Mass difference after water immersion"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T03","name_en":"Chemical resistance","standard_as_printed":"EN ISO 175","criterion":{"requirement":"No residue or precipitate"},"conditions":{"immersion_days":7,"media":["5% sulphuric acid","10% hydrochloric acid","Gasoline","10% sodium chloride"]},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T04","name_en":"Flame resistance","standard_as_printed":"EN ISO 1066","criterion":{"requirement":"Non-flaming or self-extinguishing; source wording"},"conditions":{"method":"Expose one end to a flame and observe the distance at which combustion stops","reference_status":"Designation transcribed as printed; applicability and edition not independently verified"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T05","name_en":"Impact resistance","standard_as_printed":null,"criterion":{"requirement":"No crack of 6 mm diameter; source comparator is not specified"},"conditions":{"conditioning_C":30,"conditioning_hours":null,"drop_mass_g":1000,"drop_height_mm":1200,"angle_deg":90},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T06","name_en":"Heat and flexibility resistance","standard_as_printed":null,"criterion":{"permanent_deviation_max_deg":5},"conditions":{"conditioning_C":60,"conditioning_hours":2,"bends":5,"bend_angle_deg":90,"bend_period_minutes":2,"recovery_seconds":30},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T07","name_en":"Elastic flexibility","standard_as_printed":null,"criterion":{"requirement":"No cracking or breakage"},"conditions":{"method":"Horizontal specimen is pressed from 300 mm above until both ends touch; test concave and convex directions"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T08","name_en":"Flexural strength","standard_as_printed":"EN ISO 178","criterion":{"minimum_MPa":500},"conditions":{"method":"Three-point bending on a specimen prepared according to the referenced standard"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T09","name_en":"Ultraviolet resistance","standard_as_printed":null,"criterion":{"requirement":"No colour difference"},"conditions":{"UV_exposure_hours":16,"lamp_and_irradiance":"Not specified"},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T10","name_en":"Deflection","standard_as_printed":null,"criterion":{"maximum_deflection_mm":254},"conditions":{"cantilever_specimen_length_mm":1220,"free_end_mass_g":910,"directions":["Concave","Convex"]},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T11","name_en":"Cold and flexibility resistance","standard_as_printed":null,"criterion":{"requirement":"No cracking or breakage","permanent_deviation_max_deg":5},"conditions":{"conditioning_C":-30,"conditioning_hours":2,"bends":5,"bend_angle_deg":90,"bend_period_minutes":2,"recovery_seconds":30},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"},{"id":"S5-T12","name_en":"Cold impact resistance","standard_as_printed":null,"criterion":{"requirement":"No crack of 6 mm diameter; source comparator is not specified"},"conditions":{"conditioning_C":-30,"conditioning_hours":2,"drop_mass_g":900,"drop_height_mm":1500,"angle_deg":90},"_source":"S5 page 2 test table","status":"PUBLISHED_MANUFACTURER_CRITERION_NOT_INDEPENDENT_TEST_RESULT"}]; IndependentTestReport: Not supplied; published criteria do not constitute product-specific test results; SourceReference: Contract-manufacturer technical document, 2019-02-28, page 2; internal reference S5; SourceDrawingSHA256: 11176797327b2640d816b426d3dbfae68cf4746ad806e2d49769519e0a67fc50; FamilyDefinitionSHA256: 21c50d0a2c026501a3fff76b24bf2dbbec39e5228e4dbc2c162f7b6ec81eb55a

# IfcSurfaceFeature: APPEARANCE_SURFACE (2)
In: Local product coordinate container
Description: Traffic Industries / MIR GROUP; Reflector surface - thickness unspecified; PredefinedType: USERDEFINED; Material: Reflector surface - thickness unspecified
Name
Front reflector surface | Pset_TI_Component_reflector_front - ProductCode: TI-YKD-1300-WHITE-YY; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: reflector_front; ComponentMaterial: Reflector surface - thickness unspecified; Role: APPEARANCE_SURFACE; LengthUnit: mm
Back reflector surface | Pset_TI_Component_reflector_back - ProductCode: TI-YKD-1300-WHITE-YY; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: reflector_back; ComponentMaterial: Reflector surface - thickness unspecified; Role: APPEARANCE_SURFACE; LengthUnit: mm
